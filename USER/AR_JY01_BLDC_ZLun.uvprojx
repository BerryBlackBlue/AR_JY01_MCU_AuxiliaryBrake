# Keil uVision project AR_JY01_BLDC_ZLun.uvprojx, settings and files
target AR_JY01_BLDC_MCU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AR_JY01_BLDC_MCU +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\timer;..\HARDWARE\pwm;..\USER;..\HARDWARE\FILTER;..\HARDWARE\RIGHTREAR;..\HARDWARE\LEFTREAR;..\HARDWARE\CAN;..\HARDWARE\RIGHTFRONT;..\HARDWARE\LEFTFRONT;..\HARDWARE\PEDAL;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/uart/: uart.c
    ../HARDWARE/RIGHTREAR/: rightrear.c
    ../HARDWARE/LEFTREAR/: leftrear.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/RIGHTFRONT/: rightfront.c
    ../HARDWARE/LEFTFRONT/: leftfront.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group README
    ../: Readme.txt
